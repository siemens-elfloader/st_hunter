# IAR project SieICQ.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  postbuild: "obexcopy.exe" $EXE_DIR$\SieGet.elf \MMCard\ZBin\Daemons\SieGet.elf
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  postbuild: "obexcopy.exe" $EXE_DIR$\SieGet.elf \Data\ZBin\Daemons\SieGet.elf
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X75
  postbuild: as above
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: file_works.cpp file_works.h iconpack.cpp iconpack.h langpack.cpp langpack.h log.cpp log.h main.cpp main.h mem.cpp mem.h sieicq_ipc.h sieicqmain.cpp sieicqmain.h string_util.cpp string_util.h
  group bcfg
    ./: conf_loader.c conf_loader.h config_data.c config_data.h
  group c++
    ../c++/: _cpp.C _cpp2.cpp
  group gui
    ./: contact_list.cpp contact_list.h csm.cpp csm.h gui.cpp gui.h log_widget.cpp log_widget.h rect_patcher.cpp rect_patcher.h
  group ICQ
    ./: icq.cpp icq.h icq_packet.cpp icq_packet.h icqsocket.cpp icqsocket.h
  group inc
    ./: func.asm include.h macros.h Random.h TODO
  group net
    ./: dns.cpp dns.h socket.cpp socket.h
