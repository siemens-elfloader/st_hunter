# IAR project htc.ewp, settings and files
configuration SGOLD (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NEWSGOLD (ARM)
  as the first configuration, except:
configuration ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: adreslist.c conf_loader.c config_data.c fileman.c main.c readimg.c string_works.c ussd_process.c
    $EW_DIR$/arm/GameGear/jpeglib/: jpeglib.r79
    $EW_DIR$/arm/fastrun3_src_191/: ScreenShot.c
    $EW_DIR$/arm/: Swi.asm
