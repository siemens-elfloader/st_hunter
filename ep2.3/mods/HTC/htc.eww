<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>Z:\D\elf\arm\Casher\AltMyMenu.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\htc.ewp</path>
  </project>
  <project>
    <path>Z:\D\elf\arm\smsman\SMSman.ewp</path>
  </project>
  <batchBuild/>
</workspace>


