# IAR project MNUEdit.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT\MNUEdit\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_RU
  postbuild: "obexcopy.exe" Release_ELKA\Exe\MNUEdit.elf \Data\MNUEdit.elf
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT\ElfStart\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c fileman.c func.asm main.c menu.c shortcuts_menu.c
