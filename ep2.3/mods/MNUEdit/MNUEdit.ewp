# IAR project MNUEdit.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: LANG_RU
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_RU
  XLINK.XclFile: G:\Pasha\elf\_MY_PROJECT_\NATICQ\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; LANG_RU
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_EN (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: LANG_EN
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD_EN (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; LANG_EN
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA_EN (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_EN
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c fileman.c func.asm main.c menu.c shortcuts_menu.c
