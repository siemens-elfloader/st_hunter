# IAR project NATICQ.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration ELKA2 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; BCFG
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\naticq_mod\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration kluchnik (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; UIN_WRITE; kluchnik; BCFG
  postbuild: "obexcopy.exe" Release_ELKA\Exe\NatICQ.elf \MMCard\ZBin\NatICQ\NatICQ.elf
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\naticq_mod\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NEWSGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; BCFG
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\naticq_mod\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: BCFG
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\naticq_mod\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h main.c
    ../: config_data.c
