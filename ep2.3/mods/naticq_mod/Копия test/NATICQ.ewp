# IAR project NATICQ.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.IExtraOptions: --separate_cluster_for_initialized_variables
  postbuild: "obexcopy.exe" $EXE_DIR$\NatICQ.elf \MMCard\ZBin\NatICQ\NatICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  postbuild: obexcopy.exe $EXE_DIR$\NATICQ.elf \Data\Zbin\NatICQ\NATICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; UIN_WRITE
  postbuild: "obexcopy.exe" Release_ELKA\Exe\NatICQ.elf \MMCard\ZBin\NatICQ\NatICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X75
  postbuild: "obexcopy.exe" Release\Exe\NATICQ.elf \MMCard\NATICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Evilfox_icq (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; EVILFOX; UIN_WRITE
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration ESKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; UIN_WRITE
  postbuild: "obexcopy.exe" $EXE_DIR$\NatICQ.elf \MMCard\NatICQ.elf
  XLINK.XclFile: $PROJ_DIR$.xcl
  XLINK.XExtraOptions: -ynpra
configuration 2nd_asja (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; EVILFOX
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration ELKA2 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; UIN_WRITE; SECOND_NATICQ
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration kluchnik (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; UIN_WRITE; kluchnik
  postbuild: "obexcopy.exe" $EXE_DIR$\NatICQ.elf \MMCard\NatICQ.elf
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\naticq_mod\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration kluchnik2 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; UIN_WRITE; kluchnik2
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration kluch_BCFGGEN (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; UIN_WRITE; kluchnik; BCFGGEN
  postbuild: "obexcopy.exe" $EXE_DIR$\NatICQ.elf \MMCard\NatICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h main.c
