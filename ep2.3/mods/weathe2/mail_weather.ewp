# IAR project mail_weather.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: C:\WINDOWS\System32\irftp.exe $TARGET_PATH$
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c print.r79
