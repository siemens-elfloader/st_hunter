# IAR project AltMyMenu.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: RU
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; RU
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; RU; kluchnik
  postbuild: "obexcopy.exe" $EXE_DIR$\DrawList3.elf \MMCard\DrawList3.elf
  XLINK.XclFile: ..\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm main.c print.r79
