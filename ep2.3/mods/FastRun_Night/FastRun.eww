<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FastRun.ewp</path>
  </project>
  <project>
    <path>F:\&#x42D;LF\Iar1\arm\fastrun3_src_191\FastRun.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$4\FastRun.ewp</path>
  </project>
  <batchBuild/>
</workspace>


