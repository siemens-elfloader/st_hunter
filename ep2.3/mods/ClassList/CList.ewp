# IAR project CList.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  postbuild: $EXE_DIR$\send.bat
  XLINK.XclFile: D:\pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: _cpp2.cpp csm.cpp dialog.cpp File.cpp List.cpp main.cpp mlist.cpp
    ../AltMyMenu/: func.asm
  group headers
    ./: csm.h dialog.h File.h List.h mlist.h patch_rect.h
