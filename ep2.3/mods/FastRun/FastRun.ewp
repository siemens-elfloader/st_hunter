# IAR project FastRun.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: "obexcopy.exe" $EXE_DIR$\FastRun.elf \Data\FastRun.elf
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c print.h print.r79 ScreenShot.c
