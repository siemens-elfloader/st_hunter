# IAR project mail_weather.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  postbuild: C:\WINDOWS\System32\irftp.exe $TARGET_PATH$
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
configuration ESKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c print.r79 strings.c strings2.c
