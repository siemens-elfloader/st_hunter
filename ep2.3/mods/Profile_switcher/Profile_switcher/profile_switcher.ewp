# IAR project profile_switcher.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  XLINK.XclFile: D:\Pasha\elf\CfgEdit\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ../72754_openwith2/: conf_loader.c
    ./: config_data.c func.asm main.c
