<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\profile_switcher.ewp</path>
  </project>
  <batchBuild/>
</workspace>
