<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\iphone_saver.ewp</path>
  </project>
  <project>
    <path>D:\pasha\elf\_MY_PROJECT_\IPC_TEST\NSD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


