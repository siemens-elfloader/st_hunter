# IAR project calc.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\ARM\calc\test.xcl
configuration Release (ARM)
  as the first configuration, except:
  XLINK.XclFile: C:\Documents and Settings\Admin\Рабочий стол\flamee_m\flamee_m\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Realease_ELKA (ARM)
  as the first configuration, except:
  XLINK.XclFile: C:\Users\Дракон\Desktop\Эльфы\ARM\flameeййй\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: div.r79 func.asm main.c
