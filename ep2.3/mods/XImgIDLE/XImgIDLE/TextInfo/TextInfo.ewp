# IAR project TextInfo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: D:\Pasha\elf\Xtask\Xtask\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c main.cpp
