# IAR project NATICQ.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.IExtraOptions: --separate_cluster_for_initialized_variables
  postbuild: "obexcopy.exe" $EXE_DIR$\NatICQ.elf \MMCard\ZBin\NatICQ\NatICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; UIN_WRITE
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: X75; kluchnik2
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration ESKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration kluchnik (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; kluchnik; BCFGGEN
  postbuild: "obexcopy.exe" $EXE_DIR$\NatICQ22.elf \MMCard\NatICQ22.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration ole64 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; UIN_WRITE; ole64
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration kluchnik_iconbar (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; kluchnik; BCFG; ICONBAR
  postbuild: "obexcopy.exe" $EXE_DIR$\NATICQ_iconbar.elf \MMCard\NATICQ_iconbar.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration kluchnik_debug (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA; kluchnik; BCFG; ICONBAR; DEBUG
  postbuild: "obexcopy.exe" $EXE_DIR$\NATICQ_dbg.elf \MMCard\NATICQ_dbg.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: addon.c auth.r79 cl_work.c conf_loader.c config_data2.c configs.c func.asm history.c main.c mainmenu.c manage_cl.c player_tags.c print.r79 screen_save.c ScreenShot.r79 select_smile.c smiles_loader.c status_change.c strings.r79
  group inc
    ./: addon.h base64.h cl_work.h conf_loader.h configs.h decode.h history.h language.h main.h mainmenu.h manage_cl.h naticq.h naticq_ipc.h player_tags.h print.h rect_patcher.h screen_save.h select_smile.h sf_mime.h smiles.h status_change.h string_util_int.h strings.h strings2.h strings3.h swilib2.h
