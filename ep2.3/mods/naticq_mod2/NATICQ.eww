<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\2ndconfig\2ndconfig.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\NATICQ.ewp</path>
  </project>
  <batchBuild/>
</workspace>


