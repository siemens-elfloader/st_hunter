# IAR project lihgt.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: main.c
