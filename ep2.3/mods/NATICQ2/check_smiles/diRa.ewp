# IAR project diRa.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NewSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; GUI_INTERFACE
  group (top)
    ../: conf_loader.c conf_loader.h config_data.c readimg.c strings.c Swi.asm
    ./: main.c smiles_loader.c
