# IAR project mail_weather.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  postbuild: C:\WINDOWS\System32\irftp.exe $TARGET_PATH$
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.IExtraOptions: --no_path_in_file_macros
  XLINK.XclFile: D:\pasha\elf\_MY_PROJECT_\test.xcl
configuration ESKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ../../SVN2/C++/: _cpp2.cpp
    ./: File.cpp func.asm List.cpp main.c strings.c
