# IAR project iphone_saver.ewp, settings and files
configuration SGOLD (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NEWSGOLD (ARM)
  as the first configuration, except:
configuration ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: "obexcopy.exe" $EXE_DIR$\iphone_saver.elf \MMCard\iphone_saver.elf
  XLINK.XclFile: k:\Pasha\elf\_MY_PROJECT_\test.xcl
  group (top)
    ./: main.c readimg.c Swi.asm
