# IAR project TextInfo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: "obexcopy.exe" $EXE_DIR$\lihgt.elf \MMCard\lihgt.elf
  XLINK.XclFile: K:\Pasha\elf\_MY_PROJECT_\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\naticq_mod2\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  XLINK.XclFile: D:\Pasha\elf\_MY_PROJECT_\naticq_mod2\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: main.cpp
