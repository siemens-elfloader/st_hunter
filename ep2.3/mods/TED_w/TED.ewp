# IAR project TED.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: C:\Мои документы\DeS\Siemens Mobile\! S75\Programs\! SVN\Elfes\TED\test.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpraw
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  postbuild: obexcopy.exe $EXE_DIR$\TED.elf \Data\ZBin\TED\TED.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpraw
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: obexcopy.exe Release_ELKA\Exe\TED.elf \MMCard\ZBin\TED\TED.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ./: config_data.c convert_format.c convert_simple.c div.r79 func.asm linework.c main.c saver.c
