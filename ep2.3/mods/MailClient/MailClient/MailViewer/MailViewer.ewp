# IAR project MailViewer.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy $EXE_DIR$\$PROJ_FNAME$.elf \Data\Zbin\EMailClient\$PROJ_FNAME$.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  postbuild: obexcopy $EXE_DIR$\$PROJ_FNAME$.elf \MMCard\Zbin\EMailClient\$PROJ_FNAME$.elf
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD
  postbuild: as above
  group (top)
    ../: conf_loader.c config_data.c
    ./: decode.cpp func.asm main.c statscreen.c
