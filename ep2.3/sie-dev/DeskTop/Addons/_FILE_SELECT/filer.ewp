# IAR project filer.ewp, settings and files
configuration SG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: obexcopy.exe $EXE_DIR$\PngExtStat.elf \Data\ZBin\utilities\PngExtStat.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  postbuild: obexcopy.exe $EXE_DIR$\PngExtStat.elf \MMCard\ZBin\utilities\PngExtStat.elf
configuration ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: func.asm main.c
