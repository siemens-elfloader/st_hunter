# IAR project DescTop.ewp, settings and files
configuration SG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: bitmap_funcs.c conf_loader.c config_data.c func.asm main.c
    ../: strings.c
