<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\_Dt\DescTop.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Addons\extfuncs\extfuncs.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Addons\_FILE_SELECT\filer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Addons\Window_man\W_MAN.ewp</path>
  </project>
  <batchBuild/>
</workspace>


