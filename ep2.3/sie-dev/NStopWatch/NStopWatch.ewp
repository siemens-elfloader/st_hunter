# IAR project NStopWatch.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: link.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: link.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: SGOLD
  XLINK.XclFile: link.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c config_data.c config_skin.c func.asm graphics.c interface.c lang.c main.c notify.c stopwatch.c write_read.c
