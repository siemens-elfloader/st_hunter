# IAR project iGPRS.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: SGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\GPRS MAN\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\test.xcl
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\test.xcl
  group (top)
    ./: conf_loader.c config_data.c func.asm gui.c main.c
    ../inc/: csm.c ipc.c str.c
