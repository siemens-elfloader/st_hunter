# IAR project NATICQ_IAR_old.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  postbuild: "obexcopy.exe" Release\Exe\NatICQ.elf \MMCard\ZBin\NatICQ\NatICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG
  postbuild: "obexcopy.exe" $EXE_DIR$\NATICQ.elf Data\Zbin\NatICQ\NATICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG
  postbuild: "obexcopy.exe" Release_ELKA\Exe\NatICQ.elf \MMCard\ZBin\NatICQ\NatICQ.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_X75 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG; X75
  postbuild: as above
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c config_data.c func.asm history.c main.c main.h mainmenu.c mainmenu.h send_ipc.c status_change.c status_change.h
