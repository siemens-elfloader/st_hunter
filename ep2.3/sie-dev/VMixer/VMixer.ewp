# IAR project VMixer.ewp, settings and files
configuration Release_ELKA (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
configuration Release_SGold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  group (top)
    ./: conf_loader.c config_data.c config_skin.c func.asm gui.c ipc.c keyhook.c main.c
