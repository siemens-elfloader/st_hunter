# IAR project MC_Faust.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: D:\ARM\mc_grafic_gui\mc\TEST.XCL
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  XLINK.XclFile: test.xcl
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD_X75
  XLINK.XclFile: test.xcl
configuration Release_ELKA_LOG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LOG
  XLINK.XclFile: test.xcl
configuration Release_NSG_LOG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; LOG
  XLINK.XclFile: test.xcl
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: test.xcl
configuration Release_ELKA_MUI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; DUMP_MUI
  XLINK.XclFile: test.xcl
configuration Release_SGOLD_LOG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: LOG
  XLINK.XclFile: test.xcl
  group (top)
    ./: 7zslib.c about.c arch.c Bookmarks.c ColorMap.c conf_loader.c CONFIG.C config_data.c DPROP.C ENCODE.C EXTS.C FileOp.c flash.c FN_LIST.C FPROP.C FSLIB.C FUNC.ASM GUI.C KEYS.C KRNL.C MAIN.C md5.c MENUS.C MUI.C NewMenu.c packer.c popup.c quicksort.c ScreenMake.c seach.c secret.c SetResource.c SLIB.C Sortmc.c TextInput.c Ziplib.c ZSLIB.C
  group 7Zip
    7Z/: 7zAlloc.c 7zBuffer.c 7zCrc.c 7zDecode.c 7zExtract.c 7zHeader.c 7zIn.c 7zItem.c 7zMethodID.c LzmaDecode.c
  group Inc
    inc/: ColorMap.h CONFIG.H Encode.h EXTS.H gui.h LNG.H MC.H MUI.H SORT.H zslib.h
    Inc/: revision.h
  group ZLib
    ZLib/: ADLER32.C COMPRESS.C CRC32.C CRC32.H DEFLATE.C DEFLATE.H INFFAST.C INFFAST.H INFFIXED.H INFLATE.C INFLATE.H INFTREES.C INFTREES.H translation.h TREES.C TREES.H UNCOMPR.C Zconf.h zconf.in.h ZLIB.H ZUTIL.C ZUTIL.H
  group ZLib/minizip
    ZLib/MINIZIP/: CRYPT.H IOAPI.C IOAPI.H UNZIP.C UNZIP.H ZIP.C ZIP.H
