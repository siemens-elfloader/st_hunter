# IAR project NatAlarm.ewp, settings and files
configuration Release_ELKA (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  group (top)
    ./: color.c ColorMap.c func.asm main.c
