# IAR project CallWriter.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: after.cmd Release_SGOLD\Exe\ CallRecorder_SGOLD.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: after.cmd Release_ELKA\Exe\ CallRecorder_ELKA.elf
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NEWSGOLD
  postbuild: after.cmd Release_NEWSGOLD\Exe\ CallWriter_NEWSGOLD.elf
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c
  group call
    call/: call.h
  group obs
    obs/: obs.h
