# IAR project Ping-Pong.ewp, settings and files
configuration Release_ELKA (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  prebuild: C:\arm\pp\Release_ALL\delete.bat
  postbuild: C:\arm\pp\Release_ALL\create.bat
  XLINK.XclFile: C:\arm\pp\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: SG; X75
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NEWSGOLD
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c
  group h_files
    ./: conf_loader.h keys.h lang.h main.h pp.h Redraw.h save.h
