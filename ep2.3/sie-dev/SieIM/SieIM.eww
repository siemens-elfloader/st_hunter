<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\datelib\datelib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dbglib\dbglib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\gprslib\gprslib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ICQ\ICQ.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LibManager\LibManager.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\mesglib\mesglib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SieIM\SieIM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\strlib\strlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\typelib\typelib.ewp</path>
  </project>
  <batchBuild/>
</workspace>


