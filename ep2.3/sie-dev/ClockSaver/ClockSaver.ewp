# IAR project ClockSaver.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpannl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ELKA; NEWSGOLD
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  group (top)
    ./: cfg_param.h conf_loader.cpp conf_loader.h config_data.cc csgui.cpp csgui.h func.asm keyhook.cpp keyhook.h main.cpp main.h print.h print.r79
  group CPP
    CPP/: _cpp.C _cpp2.cpp csm.cpp csm.h gui.cpp gui.h
