-carm
-Z(CODE)PATCH_BODY,CODE,DATA_I,DATA_ID,INITTAB=A0FC1F00-FFFFFFFF
-Z(CODE)PATCH_DRAWOBJECT=A00A2E74-FFFFFFFF
