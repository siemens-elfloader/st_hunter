# IAR project drawhook.ewp, settings and files
configuration CX75v25 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: SCR_132X176; CX75sw25
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX75v25.txt
  XLINK.XclFile: config\CX75sw25.xcl
configuration S65v58 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SCR_132X176; S65sw58
  AARM.ADefines: NOTALIGN
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\S65v58.txt
  XLINK.XclFile: config\S65sw58.xcl
configuration CX70v56 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SCR_132X176; CX70sw56
  AARM.ADefines: NOTALIGN
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX70v56.txt
  XLINK.XclFile: config\CX70sw56.xcl
configuration SL65v53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SCR_130X130; SL65sw53
  AARM.ADefines: NOTALIGN
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\SL65v53.txt
  XLINK.XclFile: config\SL65sw53.xcl
configuration CX6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SCR_132X176; CX6Csw50
  AARM.ADefines: NOTALIGN
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX6Cv50.txt
  XLINK.XclFile: config\CX6Csw50.xcl
  group (top)
    ./: drawalpha.c drawhook.asm
    config/: sub_CX6Csw50.asm
