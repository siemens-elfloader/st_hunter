-carm
-Z(CODE)CODE,INITTAB,DATA_ID,DATA_C,CONFIG_DATA_ID=A1359A00-FFFFFFFF
-Z(CODE)HOOK=A0B12CFC-FFFFFFFF
-Z(DATA)CONFIG_DATA_Z=A8D80400-FFFFFFFF
-Z(DATA)CONFIG_DATA_I=A8D80410-FFFFFFFF
