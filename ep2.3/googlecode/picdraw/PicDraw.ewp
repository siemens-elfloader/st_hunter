# IAR project PicDraw.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  postbuild: upload2phone.cmd
  XLINK.XclFile: PicDraw.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm main.c PicDraw.xcl
