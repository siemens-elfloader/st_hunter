# IAR project nse_elf.ewp, settings and files
configuration SGold x65 (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration SGold x75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: X75
  AARM.ADefines: X75
  group (top)
    ./: addfunc.asm conf_loader.c config_data.c func.asm func_ext.c main.c
