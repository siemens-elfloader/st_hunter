# IAR project nse_patch.ewp, settings and files
configuration SL65v53 (ARM)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: SL65sw53
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: SL65sw53
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\SL65v53.txt
  XLINK.XclFile: config\SL65sw53.xcl
configuration CX75v25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CX75sw25
  AARM.ADefines: C75sw25
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX75v25.txt
  XLINK.XclFile: config\CX75sw25.xcl
configuration S65v58 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: S65sw58
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\S65v58.txt
  XLINK.XclFile: config\S65sw58.xcl
configuration C75v22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: C75sw22
  AARM.ADefines: C75sw22
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\C75v22.txt
  XLINK.XclFile: config\C75sw22.xcl
  group (top)
    ./: main.asm
