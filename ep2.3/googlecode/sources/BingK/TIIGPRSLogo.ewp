# IAR project TIIGPRSLogo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: dl-stnl0.r79
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
configuration E71Csw41 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ E71Cv41
  XLINK.XclFile: E71Csw41.xcl
  group (top)
    ./: conf_loader.c config_data.c draw.c main.asm
