# IAR project CodeShowPatch.ewp, settings and files
configuration E71Cv41 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; E71Cv41
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; ELKA; E71Cv41
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ E71Cv41
  XLINK.XclFile: E71Cv41.xcl
configuration S7Cv47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; S7Cv47
  AARM.ADefines: NEWSGOLD; S7Cv47
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ S7CV47
  XLINK.XclFile: S7Cv47.xcl
configuration ELC1v41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; ELC1v41
  AARM.ADefines: NEWSGOLD; ELKA; ELC1v41
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ ELC1v41
  XLINK.XclFile: ELC1v41.xcl
configuration SK6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SK6Cv50
  AARM.ADefines: SK6Cv50
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ SK6Cv50
  XLINK.XclFile: SK6Cv50.xcl
configuration S68Cv51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; S68Cv51
  AARM.ADefines: NEWSGOLD; S68Cv51
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ S68Cv51
  XLINK.XclFile: S68Cv51.xcl
configuration M81Cv51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; M81Cv51
  AARM.ADefines: NEWSGOLD; M81Cv51
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ M81Cv51
  XLINK.XclFile: M81Cv51.xcl
configuration CX6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CX6Cv50
  AARM.ADefines: CX6Cv50
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ CX6Cv50
  XLINK.XclFile: CX6Cv50.xcl
configuration S6Cv53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: S6Cv53
  AARM.ADefines: S6Cv53
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ S6Cv53
  XLINK.XclFile: S6Cv53.xcl
configuration M6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: M6Cv50
  AARM.ADefines: M6Cv50
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ M6Cv50
  XLINK.XclFile: M6Cv50.xcl
configuration CX7Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CX7Cv50
  AARM.ADefines: CX7Cv50
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ CX7Cv50
  XLINK.XclFile: CX7Cv50.xcl
configuration CX7Av25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CX7Av25
  AARM.ADefines: CX7Av25
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ CX7Av25
  XLINK.XclFile: CX7Av25.xcl
configuration C81Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; C81Cv50
  AARM.ADefines: NEWSGOLD; C81Cv50
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ C81Cv50
  XLINK.XclFile: C81Cv50.xcl
configuration SL7Cv47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; SL7Cv47
  AARM.ADefines: NEWSGOLD; SL7Cv47
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ SL7CV47
  XLINK.XclFile: SL7Cv47.xcl
configuration SL6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SL6Cv50
  AARM.ADefines: SL6Cv50
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ SL6Cv50
  XLINK.XclFile: SL6Cv50.xcl
configuration C6Cv53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: C6Cv53
  AARM.ADefines: C6Cv53
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ C6Cv53
  XLINK.XclFile: C6Cv53.xcl
configuration C7Cv22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: C7Cv22
  AARM.ADefines: C7Cv22
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ C7Cv22
  XLINK.XclFile: C7Cv22.xcl
  group (top)
    ./: check.c main.asm
