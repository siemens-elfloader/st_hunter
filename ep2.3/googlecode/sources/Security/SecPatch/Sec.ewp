# IAR project Sec.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: Sec.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: func.asm main.c
