# IAR project FreePaste.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: bookmark.c bookmark.h code.c code.h conf_loader.c conf_loader.h config.c func.asm main.c
