# IAR project Backup of SieTxtView.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: SieTxtView.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NewSGold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: SieTxtView.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGold (ARM)
  as the first configuration, except:
  XLINK.XclFile: SieTxtView.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: bookmark.c bookmark.h code.c code.h conf_loader.c conf_loader.h config.c func.asm main.c
