# IAR project KeyExten.ewp, settings and files
configuration NSG (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration SG (ARM)
  as the first configuration, except:
  XLINK.XclFile: F:\SVN\KeyExten\test.xcl
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c
