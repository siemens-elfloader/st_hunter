# IAR project screen note.ewp, settings and files
configuration newsgold (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: F:\SVN\cn\ScreenNote\screen note.xcl
  XLINK.XExtraOptions: -ynpra
configuration sgold (ARM)
  as the first configuration, except:
  XLINK.XclFile: I:\桌面\临时\手机编程\SeCode\Screen Note\screen note.xcl
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c
