-carm
-Z(CODE)CODE,DATA_C,CONFIG_DATA_C=A0FC7D00-FFFFFFFF

-Z(CODE)PATCH_ENTER1=A048DB44-A048DB4B

-Z(CODE)PATCH_ENTER2=A04998A8-A04998AF

-Z(CODE)PATCH_ENTER3=A017CF90-A017CF94
