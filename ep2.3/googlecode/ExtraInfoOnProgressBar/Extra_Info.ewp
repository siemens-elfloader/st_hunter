# IAR project Extra_Info.ewp, settings and files
configuration CX75_13 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; ENABLE_PARAMS
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ENABLE_PARAMS
  postbuild: ..\tools\elf2vkp.exe $EXE_DIR$\$PROJ_FNAME$.elf $EXE_DIR$\$PROJ_FNAME$.vkp e:\\fubu\\65\\cx75v13.bin
  XLINK.XclFile: cx75_13.xcl
configuration E71_45 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  postbuild: ..\elfloader\elf2vkp.exe $EXE_DIR$\$PROJ_FNAME$.elf $EXE_DIR$\$PROJ_FNAME$.vkp C:\\2.bin
  XLINK.XclFile: e71_45.xcl
configuration SK65_50 (ARM)
  as the first configuration, except:
  postbuild: ..\elfloader\elf2vkp.exe $EXE_DIR$\$PROJ_FNAME$.elf $EXE_DIR$\$PROJ_FNAME$.vkp C:\\1.bin
  XLINK.XclFile: sk65_50.xcl
configuration CX7Av25 (ARM)
  as the first configuration, except:
  postbuild: ..\tools\elf2vkp.exe $EXE_DIR$\$PROJ_FNAME$.elf $EXE_DIR$\$PROJ_FNAME$.vkp e:\\fubu\\65\\CX7Av25.bin
  group (top)
    ./: additional.c conf_loader.c config_data.c main.asm rets_SK65sw50.asm sk65_50.xcl
