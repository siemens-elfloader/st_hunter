# IAR project DisplayShooter.ewp, settings and files
configuration newsgold (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: E:\ARM\Моё\DisplayShooter\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration sgold (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  XLINK.XclFile: E:\ARM\Моё\Test\test.xcl
configuration elka (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: conf_loader.c config_data.c func.asm jcapimin.c jcapistd.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcphuff.c jcprepct.c jcsample.c jdatadst.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jmemmgr.c jutils.c main.c
