# IAR project IME_PINYIN.ewp, settings and files
configuration E71Csw41 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; E71Csw41
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; ELKA; E71Csw41
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ E71C
  XLINK.XclFile: E71Csw41.xcl
configuration ELC1sw41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; ELC1sw41
  AARM.ADefines: NEWSGOLD; ELKA; ELC1sw41
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ ELC1
  XLINK.XclFile: ELC1sw41.xcl
configuration S7Csw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; S7Csw47
  AARM.ADefines: NEWSGOLD; S7Csw47
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ S7C
  XLINK.XclFile: S7Csw47.xcl
configuration S68Csw51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; S68Csw51
  AARM.ADefines: NEWSGOLD; S68Csw51
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ S68C
  XLINK.XclFile: S68Csw51.xcl
configuration M81Csw51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; M81Csw51
  AARM.ADefines: NEWSGOLD; M81Csw51
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ M81Cv51
  XLINK.XclFile: M81Csw51.xcl
  group (top)
    ./: addr.h IME_PINYIN.asm IME_PINYIN_1_4.asm
