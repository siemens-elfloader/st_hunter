# IAR project MediaPlayer.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptnnl8n.h
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.PreInclude: swilib.h
  XLINK.XclFile: elf.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: div.r79 func.asm Main.c
  group AAC
    AAC/AACDEC/: AAC_FILE (1).c AAC_FILE (10).c AAC_FILE (11).c AAC_FILE (12).c AAC_FILE (13).c AAC_FILE (14).c AAC_FILE (15).c AAC_FILE (16).c AAC_FILE (17).c AAC_FILE (18).c AAC_FILE (19).c AAC_FILE (2).c AAC_FILE (20).c AAC_FILE (21).c AAC_FILE (22).c AAC_FILE (23).c AAC_FILE (24).c AAC_FILE (25).c AAC_FILE (3).c AAC_FILE (4).c AAC_FILE (5).c AAC_FILE (6).c AAC_FILE (7).c AAC_FILE (8).c AAC_FILE (9).c AAC_FILE.c aacdec.c aactabs.c
  group AMR
    AMR/: AmrPlayer.c dec_acelp.c dec_dtx.c dec_gain.c dec_if.c dec_lpc.c dec_main.c dec_rom.c dec_util.c if_rom.c
  group MP3
    MP3/mp3dec/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
  group NSF
    NSF/: 6502.C
  group Player
    ./: Screen.c
  group XM
    MOD/Judas/: JUDASTBL.C
  group ZIP
    zlib/: ADLER32.C CRC32.C DEFLATE.C INFFAST.C INFLATE.C INFTREES.C TREES.C UNCOMPR.C ZUTIL.C
