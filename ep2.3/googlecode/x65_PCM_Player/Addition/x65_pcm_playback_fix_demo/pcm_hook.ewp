# IAR project pcm_hook.ewp, settings and files
configuration SL65v53 (ARM)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: SL65v53
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: SL65v53
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\SL65v53.txt
  XLINK.XclFile: config\SL65v53.xcl
configuration S65v58 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: S65v58
  AARM.ADefines: S65v58
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\S65v58.txt
  XLINK.XclFile: config\S65v58.xcl
configuration CX70v56 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CX70v56
  AARM.ADefines: CX70v56
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX70v56.txt
  XLINK.XclFile: config\CX70v56.xcl
configuration CX75v25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CX75v25
  AARM.ADefines: CX75v25
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX75v25.txt
  XLINK.XclFile: config\CX75v25.xcl
configuration C75v22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: C75v22
  AARM.ADefines: C75v22
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\C75v22.txt
  XLINK.XclFile: config\C75v22.xcl
configuration CF75v23 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CF75v23
  AARM.ADefines: CF75v23
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CF75v23.txt
  XLINK.XclFile: config\CF75v23.xcl
configuration CX75v13 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CX75v13
  AARM.ADefines: CX75v13
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\CX75v13.txt
  XLINK.XclFile: config\CX75v13.xcl
  group (top)
    ./: main.c pcm_hook.asm
