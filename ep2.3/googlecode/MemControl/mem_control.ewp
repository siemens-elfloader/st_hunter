# IAR project mem_control.ewp, settings and files
configuration SL65v53 (ARM)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: SL65sw53
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: SL65sw53
  postbuild: postbuild\postbuild.cmd $PROJ_DIR$ $EXE_DIR$ config\SL65v53.txt
  XLINK.XclFile: config\SL65v53.xcl
  group (top)
    ./: blockseek.c browser.asm java.asm main.asm
